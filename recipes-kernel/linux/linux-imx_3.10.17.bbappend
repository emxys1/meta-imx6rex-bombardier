FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"
SRC_URI += "file://0001-Initial-change-Board-name-change.patch"
SRC_URI += "file://0001-MAX11801-removed-from-DTSI.patch"
